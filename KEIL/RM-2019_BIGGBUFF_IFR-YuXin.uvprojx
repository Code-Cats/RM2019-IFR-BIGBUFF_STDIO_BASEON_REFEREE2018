# Keil uVision project RM-2019_BIGGBUFF_IFR-YuXin.uvprojx, settings and files
target RM-2019_BIGGBUFF_IFR-YuXin (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM-2019_BIGGBUFF_IFR-YuXin +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\USER;..\STM32MCU;..\STM32MCU\FWLIB\inc;..\STM32MCU\CORE;..\ROBOT\ALGO;..\ROBOT\ANALYSIS;..\ROBOT\APP;..\ROBOT\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
    ../: README.md
  group BSP
    ../ROBOT/BSP/: bsp.c can1.c can2.c gpio.c pwm.c timer6.c uart4_gyro.c uart5_vision.c usart1_remote.c usart3_judge.c usart6_viceboard.c
  group APP
    ../ROBOT/APP/: bigbuff_6623.c control.c gpioctrl.c hit_recognition.c protect.c yun.c
  group ANALYSIS
    ../ROBOT/ANALYSIS/: can1_analysis.c can2_analysis.c judge_analysis.c
  group STM32MCU
    ../STM32MCU/: stm32f4xx_it.c system_stm32f4xx.c
    ../STM32MCU/CORE/: startup_stm32f40_41xxx.s
    ../STM32MCU/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group ALGO
    ../ROBOT/ALGO/: delay.c pid.c
